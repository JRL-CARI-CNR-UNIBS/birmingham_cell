Commit message: General_env tests to do

File: birmingham_cell_description/urdf/cylinder_hole.xacro (robot description, xacro)
@@ -18,5 +18,5 @@
       </geometry>
     </visual>
-    <collision>
+    <collision concave="yes">
       <origin xyz="0 0 0" rpy="0 0 0" />
       <geometry>
